## Config.in
```kconfig
config FREETZ_PACKAGE_CWTEXT
	bool "Cwtext 0..96 (binary only)"
	select FREETZ_LIB_libutil
	default n
	help
		Cwtext converts plain ASCII to International Morse Code.
```
